# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,HSE_VALUE=8000000
  c include: ..\inc;..\..\bsp4Elink\inc;..\..\..\STM32_Lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32_Lib\STM32F4x7_ETH_Driver\inc;..\Third_Party\lwip_v1.3.2\src\include\lwip;..\Third_Party\lwip_v1.3.2\src\include\netif;..\Third_Party\lwip_v1.3.2\src\include\ipv4;..\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Third_Party\lwip_v1.3.2\src\include;..\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\..\..\STM32_Lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../src/: main.c netconf.c stm32f4x7_eth_bsp.c stm32f4xx_it.c fs.c serial_debug.c httpd_cgi_ssi.c httpd.c system_stm32f4xx.c
  group board
    ../../bsp4Elink/src/: delay.c uart.c timer.c
  group periph
    ../../../STM32_Lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
    ../../../STM32_Lib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LwIP
    ../Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
